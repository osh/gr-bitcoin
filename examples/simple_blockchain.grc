<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>bitcoin_blockchain_source</key>
<param><key>id</key><value>bitcoin_blockchain_source_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>simple_blockchain</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<connection><source_block_id>bitcoin_blockchain_source_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>utx</source_key><sink_key>print</sink_key></connection>
</flow_graph>
